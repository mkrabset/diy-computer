LDY #00
OUT0 Y
OUT1 Y
OUT2 Y

L1:
OUT0 Y
PUSH Y
JSR FIB
POP Y

PUSH Z
POP X
OUT1 X

INC Y
JMP L1

FIB:
CMPY #01
BGT FIB2
LDZ #01
RTS

FIB2:
DEC Y
PUSH Y
JSR FIB
POP Y
PUSH Z
DEC Y
JSR FIB
STZ FTEMP
POP Z
CLC
ADDZ FTEMP
RTS

FTEMP:
B 0x00


WAIT:
LDZ #80
WAIT2:
DEC Z
BNE WAIT2
RTS
