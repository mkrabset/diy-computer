START:
LDX #01
STX C1

LP1:
LDX #01
STX C2

LP2:
LDX C1
LDY #80
STY W
W1:
DEC W
BNE W1
LDY C1

LDX C2
LDZ #40
STZ W
W2:
DEC W
BNE W2
LDZ C2

JMP MUL
RET:
LDX SL
LDY #80
STY W
W3:
DEC W
BNE W3


INC C2
LDY C2
CMPY #0A
BLE LP2
INC C1
LDY C1
CMPY #0A
BLE LP1
JMP START


MUL:
 STY AL
 STZ BL

 LDY #00
 STY AH
 STY SL
 STY SH

 LDZ #08
L1:
 LDY BL
 CLC
 ANDY #01
 BEQ L2
 LDY AL
 CLC
 ADDY SL
 STY SL
 LDY AH
 ADDY SH
 STY SH

L2:
 CLC
 ROR BL
 CLC
 ROL AL
 ROL AH
 DEC Z
 BNE L1
 JMP RET

BL:
B

AH:
B
AL:
B

SH:
B
SL:
B

C1:

B
C2:
B

W:
B

